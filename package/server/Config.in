## package/server/Config.in
```kconfig
config BR2_PACKAGE_SERVER
	bool "server"
	help
		server package.

		https://server.xyz
```
